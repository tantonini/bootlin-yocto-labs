DESCRIPTION = "Bootlinlabs Games Packagegroup"

inherit packagegroup

PACKAGES = "\
    ${PN} \
"

RDEPENDS:${PN} = "\
    ninvaders \
"
