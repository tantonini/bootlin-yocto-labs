require bootlinlabs-image-minimal.bb

DESCRIPTION = "Bootlinlabs image minimal + debug tools"

IMAGE_FEATURES += "dev-pkgs"

