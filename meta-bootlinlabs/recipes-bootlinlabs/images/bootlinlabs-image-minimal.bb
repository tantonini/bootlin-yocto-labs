IMAGE_INSTALL = "packagegroup-core-boot ${CORE_IMAGE_EXTRA_INSTALL} packagegroup-bootlinlabs-games dropbear"

inherit core-image
